# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\DELAY;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\KEY;..\TFT;..\GUI;..\HARDWARE\xpt2046;..\FATFS;..\HARDWARE\SDIO;..\HARDWARE\IIC GPIO;..\HARDWARE\IIC_OLED;..\HARDWARE\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_dma.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group DELAY
    ../DELAY/: delay.c
  group OLED
    ../HARDWARE/IIC_OLED/: iic_oled.c
    ../HARDWARE/IIC GPIO/: iic_gpio.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/xpt2046/: xpt2046.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group FATFS
    ../FATFS/: diskio.c pff.c
