# Keil uVision project STM32H7B0.uvprojx, settings and files
target FANKE_FK7B0M1_V1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: FANKE_FK7B0M1_V1
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32H7B0xx
  c include: ..\Flash;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\User\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\STM32H7xx.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../Flash/: FlashPrg.c
  group Device Description
    ../Flash/: FlashDev.c
  group Drivers/User
    ../Drivers/User/Src/: ospi_w25q64.c SystemConfig.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_mdma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
